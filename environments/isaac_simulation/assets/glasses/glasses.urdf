Commit message: pixel to position but not work

File: environments/isaac_simulation/assets/glasses/glasses.urdf (robot description, URDF)
Before this commit: robot glasses.urdf, 1 links, 0 joints
Links:
- link baseLink: mass 0.0 -> 0.1
