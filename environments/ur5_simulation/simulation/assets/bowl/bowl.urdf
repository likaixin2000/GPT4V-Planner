Commit message: Update

File: environments/ur5_simulation/simulation/assets/bowl/bowl.urdf (robot description, URDF)
Before this commit: robot bowl.urdf, 1 links, 0 joints
Links:
- link baseLink: geometry collision mesh filename=cup.obj scale=1 1 1; visual mesh filename=bowl.obj scale=1 1 1
